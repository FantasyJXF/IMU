# Keil uVision project STM32F4.uvprojx, settings and files
target 工程模板 (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\User;..\..\HARDWARE;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../User/: stm32f4xx_it.c main.c
  group HARDWARE
    ../../HARDWARE/: LED.C usart.c delay.c systick.c mpu9250.c mpu9250_spi.c ahrs.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_gpio.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DOC
    ../../Doc/: 读我.txt
